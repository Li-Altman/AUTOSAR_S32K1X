# IAR project S32K1x_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K148 NXP S32K148
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: START_FROM_FLASH; CPU_S32K148; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: StartUp_Code\devices; StartUp_Code\devices\S32K148\include; StartUp_Code\devices\S32K148\startup; StartUp_Code\devices\common; S32K1X_Cfg\MCAL_Cfg\include; S32K1X_Core\MCAL_Core\Base\include; S32K1X_Core\MCAL_Core\Dio\include; S32K1X_Core\MCAL_Core\Port\include; S32K1X_Core\MCAL_Core\SchM\include; S32K1X_Core\MCAL_Core\Det\include; S32K1X_Core\MCAL_Core\Mcu\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: StartUp_Code\devices; StartUp_Code\devices\S32K148\include; StartUp_Code\devices\S32K148\startup; StartUp_Code\devices\common; StartUp_Code
  OBJCOPY.OOCOutputFile: S32K1x_Project.hex
  ILINK.IlinkOutputFile: S32K1x_Project.out
  ILINK.IlinkIcfFile: F:\PROJ_TEST\AutoSARWorkSpace\AUTOSAR_S32K1X\S32K1X_Project\Linker_Files\S32K148_256_flash.icf
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group Linker_Files
    Linker_Files/: S32K148_256_flash.icf
  group S32K1X_Cfg/MCAL_Cfg/include
    S32K1X_Cfg/MCAL_Cfg/include/: Dio_Cfg.h Mcu_Cfg.h modules.h Port_Cfg.h Reg_eSys.h
  group S32K1X_Cfg/MCAL_Cfg/Src
    S32K1X_Cfg/MCAL_Cfg/src/: Dio_Cfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group S32K1X_Core/MCAL_Core/Mcu/include
    S32K1X_Core/MCAL_Core/Mcu/include/: Mcu.h Mcu_CMU.h Mcu_CMU_IPVersion.h Mcu_CMU_Types.h Mcu_CortexM4.h Mcu_EnvCfg.h Mcu_IPW.h Mcu_IPW_Irq.h Mcu_IPW_Types.h Mcu_PCC.h Mcu_PCC_Types.h Mcu_PMC.h Mcu_PMC_IPVersion.h Mcu_PMC_Types.h Mcu_RCM.h Mcu_RCM_Types.h Mcu_SCG.h Mcu_SCG_Types.h Mcu_SIM.h Mcu_SIM_Types.h Mcu_SMC.h Mcu_SMC_Types.h Reg_eSys_CMU.h Reg_eSys_CortexM4.h Reg_eSys_PCC.h Reg_eSys_PMC.h Reg_eSys_RCM.h Reg_eSys_SCG.h Reg_eSys_SIM.h Reg_eSys_SMC.h
  group S32K1X_Core/MCAL_Core/Mcu/src
    S32K1X_Core/MCAL_Core/Mcu/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group S32K1X_Core/MCAL_Core/Base/include
    S32K1X_Core/MCAL_Core/Base/include/: Adc_MemMap.h Can_GeneralTypes.h Can_MemMap.h Compiler.h Compiler_Cfg.h CompilerDefinition.h ComStack_Cfg.h ComStack_Types.h Crcu_MemMap.h Csec_MemMap.h Dio_MemMap.h Eep_MemMap.h Eth_GeneralTypes.h Eth_MemMap.h Fee_MemMap.h Fls_MemMap.h Fr_GeneralTypes.h Fr_MemMap.h Gpt_MemMap.h I2c_MemMap.h Icu_MemMap.h Iseled_MemMap.h Lin_GeneralTypes.h Lin_MemMap.h Mcal.h Mcem_MemMap.h Mcl_MemMap.h Mcu_MemMap.h Ocu_MemMap.h Platform_Types.h Port_MemMap.h Pwm_MemMap.h RegLockMacros.h SilRegMacros.h Soc_Ips.h Spi_MemMap.h Std_Types.h StdRegMacros.h Wdg_MemMap.h
  group S32K1X_Core/MCAL_Core/Det/include
    S32K1X_Core/MCAL_Core/Det/include/: Det.h
  group S32K1X_Core/MCAL_Core/Det/src
    S32K1X_Core/MCAL_Core/Det/src/: Det.c
  group S32K1X_Core/MCAL_Core/Dio/include
    S32K1X_Core/MCAL_Core/Dio/include/: Dio.h Dio_EnvCfg.h Dio_Gpio.h Dio_Ipw.h Reg_eSys_Gpio.h
  group S32K1X_Core/MCAL_Core/Dio/src
    S32K1X_Core/MCAL_Core/Dio/src/: Dio.c Dio_Gpio.c
  group S32K1X_Core/MCAL_Core/Port/include
    S32K1X_Core/MCAL_Core/Port/include/: Port.h Port_EnvCfg.h Port_Ipw.h Port_Port_Ci.h Port_Port_Ci_Types.h Port_Reg_eSys_Port_Ci.h Reg_eSys_Gpio.h
  group S32K1X_Core/MCAL_Core/Port/src
    S32K1X_Core/MCAL_Core/Port/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group S32K1X_Core/MCAL_Core/SchM/include
    S32K1X_Core/MCAL_Core/SchM/include/: SchM_Adc.h SchM_Can.h SchM_Crcu.h SchM_Dio.h SchM_Eep.h SchM_Eth.h SchM_Fee.h SchM_Fls.h SchM_Fr.h SchM_Gpt.h SchM_I2c.h SchM_Icu.h SchM_Iseled.h SchM_Lin.h SchM_Mcem.h SchM_Mcl.h SchM_Mcu.h SchM_Ocu.h SchM_Port.h SchM_Pwm.h SchM_RamTst.h SchM_Spi.h SchM_Wdg.h
  group S32K1X_Core/MCAL_Core/SchM/src
    S32K1X_Core/MCAL_Core/SchM/src/: SchM_Adc.c SchM_Can.c SchM_Crcu.c SchM_Dio.c SchM_Eep.c SchM_Eth.c SchM_Fee.c SchM_Fls.c SchM_Fr.c SchM_Gpt.c SchM_I2c.c SchM_Icu.c SchM_Iseled.c SchM_Lin.c SchM_Mcem.c SchM_Mcl.c SchM_Mcu.c SchM_Ocu.c SchM_Port.c SchM_Pwm.c SchM_RamTst.c SchM_Spi.c SchM_Wdg.c
  group StartUp_Code
    StartUp_Code/: startup_S32K148.S
  group StartUp_Code/devices
    StartUp_Code/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
  group StartUp_Code/devices/common
    StartUp_Code/devices/common/: s32_core_cm4.h
  group StartUp_Code/devices/S32K148/include
    StartUp_Code/devices/S32K148/include/: S32K148.h S32K148_features.h
  group StartUp_Code/devices/S32K148/startup
    StartUp_Code/devices/S32K148/startup/: system_S32K148.c system_S32K148.h
